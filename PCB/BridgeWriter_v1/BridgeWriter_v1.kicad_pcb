# Repository tmcit-ararobo-2026a/bridge-writer

File README.md:

# <bridge-writer>

<!-- 一行でプロジェクトを説明する -->
<can経由で他基板へと書き込める通信基板と基板のコード>

## 目次

1. [概要](#1-概要)
2. [ドキュメント](#2-ドキュメント)
3. [コントリビューション](#3-コントリビューション)
4. [ビルド・使い方](#4-ビルド使い方)
5. [システム構成](#5-システム構成)
6. [ライセンス](#6-ライセンス)

## 1. 概要

<!-- プロジェクトの目的・背景・解決する課題を記述 -->

## 2. ドキュメント

| ドキュメント | 説明 |
| :-: | :-: |
| [CONTRIBUTING.md](./CONTRIBUTING.md) | 開発フロー・コミット規約・コーディング規約 |
| [docs/coding-rules.md](./docs/coding-rules.md) | コーディング規約の詳細 |
| [docs/uml/](./docs/uml/) | UML図 |

## 3. コントリビューション

[CONTRIBUTING.md](./CONTRIBUTING.md) を参照してください。

## 4. ビルド・使い方

<!-- ビルドのやり方 -->
<!-- 使い方 -->

## 5. システム構成

<!-- ROS2ノード構成・STM32との通信方式・ハードウェア構成 等 -->
<!-- 依存クラスが3つ以上ある場合は docs/uml/ にUML図を作成し、ここにリンクする -->

## 6. ライセンス

本リポジトリは [MITライセンス](./LICENSE) のもとで公開されています。

## KiCad design PCB/BridgeWriter_v1/BridgeWriter_v1.kicad_pcb

Parts (part):
C1: 0.01uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C5, C6, C9, C11, C12, C13, C14, C15, C16, C17, C18, C19, C21, C22, C25, C26, C32, C33, C34, C45, C48, C49, C50, C51, C52, C53, C56, C59, C60, C62, C63, C66, C67, C68, C71, C72, C73: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C3, C4, C8, C10, C23, C24, C27, C29, C35, C61, C69, C70: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C20, C46, C47, C55: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C28, C37: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C30, C31: 2.2uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C36, C39, C40, C41: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C38: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C42, C43, C64, C65: 3pF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C44: 4700uF; CP_Radial_D16.0mm_P7.50mm
C54: 4.7uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C57, C58: 8pF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1, D2, D3, D5, D10: W; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4, D7, D9, D27, D28: ESD; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6: O; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: SB34AFC
D13: SS2040FL
D14, D18, D21, D23, D25, D29, D40: B; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D15, D19, D22, D24, D26, D30: G; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D35: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D41: R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1, FB2: 600Ω/500mA; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: USB_B; USB-4BF-103BS
J2: RJ45_Bel_SI-60062-F
J3: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
J4: Conn_01x06; PinSocket_1x06_P2.54mm_Horizontal
J5, J8: Conn_01x02; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J6, J7, J24, J25: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J9: Micro_SD_Card_Det2; microSD_HC_Hirose_DM3AT-SF-PEJM5
J10: Barrel_Jack_MountingPin; DC_Jack_18742
J11: USB_C_Receptacle_PowerOnly_6P; 632722100213
J12, J13: Conn_01x01; 5x5
JP1, JP2: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
R1, R69: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R52, R55, R63: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 12.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R6, R7: 46.9k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R8, R9, R42, R59, R60: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R13, R14, R15, R17, R18, R23, R24, R25, R26, R27, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R45, R47, R50, R51, R54, R56, R62, R64, R65: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12: 22; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R16: 1mΩ; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R19, R20, R21, R22, R61: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R28, R29: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R43: 10; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R44: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R46: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R48, R49: 50k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R53: 1M; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R57: 20k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R58: 8.06k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R66: 24k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R77, R78: 4.7kΩ; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R79: 1kΩ; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
SW1, SW3, SW4, SW5, SW6, SW7, SW9, SW10: SW_Push; switch_TVAF06-A020B-R
SW2: BOOT_MODE0; swich_SS-12D00G3
SW8: BOOT_MODE1; swich_SS-12D00G3
U1: STM32H723VGTx; LQFP-100_14x14mm_P0.5mm
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
Connections (part):
+1V2: C2.1, C5.1, C9.1, C11.1, C12.1, C13.1, C14.1, U2.3 (1V2A), U2.9 (1V2D), U2.13 (1V2O), U2.16 (1V2A), U2.18 (1V2D), U2.31 (1V2D), U2.47 (1V2D)
+3.3V: C4.2, C10.2, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C23.1, C24.1, C32.1, C39.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C62.1, C71.1, C72.1, J2.2 (TCT), J2.5 (RCT), J3.5, J9.4 (VDD), R8.1, R9.1, R13.1, R17.1, R19.1, R20.1, R21.1, R22.1, R23.1, R56.2, R61.1, R62.1, R65.2, U1.6 (VBAT), U1.11 (VDD), U1.20 (VREF+), U1.21 (VDDA), U1.27 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD), U2.7 (3V3A), U2.10 (3V3D), U2.14 (3V3A), U2.24 (3V3D), U2.36 (3V3D), U5.5 (Vio), U6.5 (Vio), U7.9 (VDDIO), U8.2 (Vout), U16.1 (V_{DD}), U17.1 (Tri_state), U17.4 (VDD), U20.5 (Vcc)
+5V: C3.1, C8.1, C36.1, C38.1, C40.1, C63.1, D8.2 (A), R15.1, R44.2, R46.1, U5.3 (VDD), U6.3 (VDD), U7.16 (VBAT), U8.3 (Vin), U10.3 (Vin), U11.4 (Vout), U11.5 (Sense), U13.4 (VCC), U14.4 (VCC), U23.3 (VIN)
+5VA: D8.1 (K), J6.3, J7.3, J24.3, J25.3
BOOTMODE: SW8.2 (B), U1.64 (PC7)
CAN_H_1: J24.4, J25.4, JP2.1 (A), U6.7 (CANH)
CAN_H_2: J6.4, J7.4, JP1.1 (A), U5.7 (CANH)
CAN_L_1: J24.2, J25.2, R1.2, U6.6 (CANL)
CAN_L_2: J6.2, J7.2, R69.2, U5.6 (CANL)
DEBUG_LED: R50.1, U1.2 (PE3)
ERROR_LED: R51.1, U1.1 (PE2)
ESP32_EN: C35.1, J4.4, R25.2, SW9.2, U3.3 (EN)
ESP32_IO0: C61.1, J4.5, R47.2, SW10.2, U3.6 (IO0)
ESP_3.3V: C27.1, C28.1, C41.1, C73.1, J4.1, R25.1, R47.1, R54.1, U3.2 (VDD), U10.2 (Vout), U15.1 (V_{DD})
Ethernet_RESET: C68.1, R20.2, SW5.2, U1.55 (PD8)
Ethernet_RX: R40.1, U1.63 (PC6)
Ethernet_TX: R39.1, U1.62 (PD15)
FAN_INA_ESP: R45.1, U3.14 (IO14), U14.6 (IN_A)
FAN_INA_STM: R32.1, U1.5 (PE6), U13.6 (IN_A)
FAN_INB_ESP: R64.1, U3.13 (IO13), U14.5 (IN_B)
FAN_INB_STM: R24.1, U1.4 (PE5), U13.5 (IN_B)
FDCAN1_RESET: C66.1, R21.2, SW3.2, U1.53 (PB14)
FDCAN1_RX: R36.1, U1.85 (PD4)
FDCAN1_TX: R35.1, U1.84 (PD3)
FDCAN2_RESET: C67.1, R22.2, SW4.2, U1.54 (PB15)
FDCAN2_RX: R38.1, U1.82 (PD1)
FDCAN2_TX: R37.1, U1.81 (PD0)
FDCAN_RXD_1: U1.95 (PB8), U6.4 (RXD)
FDCAN_RXD_2: U1.59 (PD12), U5.4 (RXD)
FDCAN_TXD_1: U1.96 (PB9), U6.1 (TXD)
FDCAN_TXD_2: U1.60 (PD13), U5.1 (TXD)
FW_UART_RX: U1.87 (PD6), U3.17 (IO4)
FW_UART_RXF: U1.98 (PE1), U3.18 (IO27)
FW_UART_TX: U1.86 (PD5), U3.16 (IO5)
FW_UART_TXF: U1.97 (PE0), U3.15 (IO28)
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (A1), D5.1 (K), D6.1 (K), D7.1 (A1)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
HS_VBUS: FB2.1, J1.1 (VBUS), R52.1, R57.2
NRST: C6.1, J3.1, SW1.2, U1.14 (NRST)
unnamed: C1.1, FB1.1, R79.1, U18.A4 (VBUS), U18.B4 (VBUS)
unnamed: C21.1, R4.2, R5.2
unnamed: C22.1, R6.2, R7.2
unnamed: C30.1, C33.1, U1.48 (VCAP)
unnamed: C31.1, C34.1, U1.73 (VCAP)
unnamed: D1.2 (A), R14.2
unnamed: D2.2 (A), R15.2
unnamed: D3.2 (A), R10.2
unnamed: D5.2 (A), R17.2
unnamed: D6.2 (A), R18.2
unnamed: D10.2 (A), R54.2
unnamed: D14.2 (A), R26.2
unnamed: D15.2 (A), R27.2
unnamed: D18.2 (A), R30.2
unnamed: D19.2 (A), R31.2
unnamed: D21.2 (A), R33.2
unnamed: D22.2 (A), R34.2
unnamed: D23.2 (A), R35.2
unnamed: D24.2 (A), R36.2
unnamed: D25.2 (A), R37.2
unnamed: D26.2 (A), R38.2
unnamed: D29.2 (A), R39.2
unnamed: D30.2 (A), R40.2
unnamed: D35.2 (A), R79.2
unnamed: D40.2 (A), R50.2
unnamed: D41.2 (A), R51.2
unnamed: J2.L1, R8.2
unnamed: J2.L3, R9.2
unnamed: J5.1, U13.1 (OUT_A)
unnamed: J5.2, U13.3 (OUT_B)
unnamed: J8.1, U14.1 (OUT_A)
unnamed: J8.2, U14.3 (OUT_B)
unnamed: J9.10 (DET_A), R13.2
unnamed: J11.A5 (CC1), U9.4 (CC1)
unnamed: J11.B5 (CC2), U9.5 (CC2)
unnamed: JP1.2 (B), R69.1
unnamed: JP2.2 (B), R1.1
unnamed: R41.2, R42.1
unnamed: R42.2, R43.1
unnamed: R48.1, U20.4
unnamed: R52.2, U21.1
unnamed: R55.2, U4.1
unnamed: R56.1, U4.4
unnamed: R59.2, U12.2 (In)
unnamed: R60.2, U12.1 (In)
unnamed: R65.1, U21.4
unnamed: R23.2, SW2.1 (A)
unnamed: R2.1, SW2.3 (C)
unnamed: R62.2, SW8.1 (A)
unnamed: R63.1, SW8.3 (C)
unnamed: R3.1, U2.8 (REST_BG)
unnamed: R11.1, U7.14 (DM)
unnamed: R12.1, U7.13 (DP)
unnamed: R58.1, U7.19 (RBIAS)
unnamed: R57.1, U7.17 (VBUS)
unnamed: R66.1, U9.6 (CFG)
unnamed: R41.1, U11.6 (Trim)
unnamed: R78.1, U18.A5 (CC1)
unnamed: R77.1, U18.B5 (CC2)
unnamed: FB1.2, U19.3 (VIN)
unnamed: R29.2, R49.1, U20.1 (+)
unnamed: FB2.2, U22.3 (VIN)
OSC: U1.12 (PH0), U17.3 (Output)
PGOOD: R44.1, U1.22 (PA0), U11.10 (PGOOD)
POWER_ADC: R28.2, R48.2, U1.23 (PA1), U20.3 (-)
POWER_MONITOR: U1.7 (PC13), U4.3
Quad_CS: U1.41 (PE11), U2.29 (CS)
Quad_D0: U1.37 (PE7), U2.32 (QD0/ADDR0)
Quad_D1: U1.38 (PE8), U2.33 (QD1/ADDR1)
Quad_D2: U1.39 (PE9), U2.34 (QD2/RDn)
Quad_D3: U1.40 (PE10), U2.35 (QD3/WRn)
Quad_SCLK: U1.36 (PB2), U2.30 (SCLK)
RXD0: J4.3, U3.24 (IO12/RXD0)
RXN: J2.6 (RD-), R5.1, U2.4 (RXIN)
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
Notes on the sheet:
電源断用一時電源
温度センサー
Bridge-Writer_v1
ESP32-C5-WROOM-1-N8R8
起動モード
DCジャック
HSE
USB PD
ブザー
MCU
LSE
FDCAN2
逆流保護
STM-DFU
電源確認
← →
5V DCDC
3.3 リニア
ESP32-C5 Wi-Fi6 Dual-Band STA-Mode
FDCAN1
合計1328mA
LED
消費電流監視
Micro_SD
通信リセット
USB_OTG_HS_ULPI
外部クロック
FDCAN x2
ファン
ねじ端子
Ethernet_10/100BACE_T
MCU RESET
電源最大入力14V 5VDCDC 3.3Vリニア電源
MCP9700T-E/TT
